# Keil uVision project driver.uvproj, settings and files
target driver (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: driver +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\src\CONFIG\inc;.\src\CORE\inc;.\src\LIBRARY\inc;.\src\FWLIB\inc;.\src\HARDWARE\inc;.\src\USER\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ./src/STARTUP/: startup_stm32f10x_hd.s
  group config
    ./src/CONFIG/src/: delay.c
  group core
    ./src/CORE/src/: core_cm3.c
  group library
    ./src/LIBRARY/src/: stm32f10x_it.c system_stm32f10x.c
  group fwlib
    ./src/FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group hardware
    ./src/HARDWARE/src/: key.c led.c usart1.c
  group user
    ./src/USER/src/: main.c
